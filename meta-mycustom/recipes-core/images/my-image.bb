DESCRIPTION = "My custom image"
LICENSE = "MIT"

IMAGE_INSTALL += " \
    packagegroup-core-boot \
    packagegroup-core-tools-base \
    nano \
    curl \
"